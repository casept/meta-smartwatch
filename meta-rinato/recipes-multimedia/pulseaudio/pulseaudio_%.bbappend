RDEPENDS:pulseaudio-server:remove:rinato = "pulseaudio-modules-droid"
